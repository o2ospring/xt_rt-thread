# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: .\applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\finsh;..\..\..\include;.;.\board;.\board\ports\include;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\CMSIS\Include;..\libraries\STM32F1xx_HAL\CMSIS\Include;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;.\xt_modules\xt_macro;.\xt_modules\xt_ir_send;.\xt_modules\xt_scom;.\xt_modules\xt_scom_sds;.\xt_modules\xt_scom_vofa;.\xt_modules\xt_cef2;.\xt_modules\xt_wiznet;.\xt_modules\xt_wiznet\Internet\DHCP;.\xt_modules\xt_wiznet\Ethernet;.\xt_modules\xt_wiznet\Ethernet\W5100;.\xt_modules\xt_wiznet\Ethernet\W5100S;.\xt_modules\xt_wiznet\Ethernet\W5200;.\xt_modules\xt_wiznet\Ethernet\W5300;.\xt_modules\xt_wiznet\Ethernet\W5500;.\xt_modules\xt_wiznet_vofa;.\modules\xt_ir_send;.\modules\xt_scom;.\modules\xt_scom_sds;.\modules\xt_scom_vofa;.\modules\xt_cef2;.\modules\xt_wiznet;.\modules\xt_wiznet_vofa;.\user\xt_ir_send_demo;.\user\xt_wiznet_demo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/xt_ir_send_demo/: app_ir_send.c app_ir_huilink.c
    ./user/xt_wiznet_demo/: app_wiznet.c
  group modules
    ./modules/xt_ir_send/: xt_ir_send_remap.h
    ./modules/xt_scom/: xt_scom_remap.h
    ./modules/xt_scom_sds/: xt_scom_sds_remap.h
    ./modules/xt_scom_vofa/: xt_scom_vofa_remap.h
    ./modules/xt_cef2/: xt_cef2_remap.h
    ./modules/xt_wiznet/: xt_wiznet_remap.h xt_wiznet_port_remap.h
    ./modules/xt_wiznet_vofa/: xt_wiznet_vofa_remap.h
  group xt_modules
    ./xt_modules/xt_macro/: xt_comdef.h xt_llist.h
    ./xt_modules/xt_ir_send/: xt_ir_send.c xt_ir_send_pwm_dma_stm32f1xx_hal.c
    ./xt_modules/xt_scom/: xt_scom.c xt_scom_stm32f1xx_hal.c xt_scom_stm32f1xx_hal_nt.c
    ./xt_modules/xt_scom_sds/: xt_scom_sds.c
    ./xt_modules/xt_scom_vofa/: xt_scom_vofa.c
    ./xt_modules/xt_cef2/: xt_cef2.c
    ./xt_modules/xt_wiznet/: xt_wiznet.c xt_wiznet_port.c xt_wiznet_hspi_stm32f1xx_hal.c
    ./xt_modules/xt_wiznet/Internet/DHCP/: dhcp.c
    ./xt_modules/xt_wiznet/Ethernet/: socket.c wizchip_conf.c
    ./xt_modules/xt_wiznet/Ethernet/W5100/: w5100.c
    ./xt_modules/xt_wiznet/Ethernet/W5100S/: w5100s.c
    ./xt_modules/xt_wiznet/Ethernet/W5200/: w5200.c
    ./xt_modules/xt_wiznet/Ethernet/W5300/: w5300.c
    ./xt_modules/xt_wiznet/Ethernet/W5500/: w5500.c
    ./xt_modules/xt_wiznet_vofa/: xt_wiznet_vofa.c
  group Applications
    applications/: main.c
    ./applications/: application.c application.h cpuusage.c app_debug.c app_debug.h
    ./: rtconfig.h
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    ./board/: board.h stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c bsp_stm32f1xx_it.c bsp_stm32f1xx_swj.c bsp_stm32f1xx_exti.c bsp_stm32f1xx_uart.c bsp_stm32f1xx_spi.c bsp_stm32f1xx_tim.c bsp_stm32f1xx_pwm.c bsp_stm32f1xx_flash_sz.c bsp_stm32f1xx_id.c bsp_stm32f1xx_crc.c bsp_stm32f1xx_wdg.c bsp_stm32f1xx_adc.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
